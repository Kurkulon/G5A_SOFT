# Keil uVision project G5ASAMD21.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMD21J17A Atmel
  pack: Keil.SAMD21_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: G5ASAMD21
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
