# Keil uVision project G5ASAMD21.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SAMD21J17A Atmel
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0001FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: G5ASAMD21.axf
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
